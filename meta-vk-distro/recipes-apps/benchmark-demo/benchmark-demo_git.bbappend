EXTRA_OEMAKE:vkrzg2lc = "'MACHINE=smarc-rzg2lc'"
EXTRA_OEMAKE:vk-d184280e = "'MACHINE=smarc-rzg2lc'"
