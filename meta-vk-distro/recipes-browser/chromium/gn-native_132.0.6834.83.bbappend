# Intentionally empty. chromium-gn-native_132.0.6834.83.bb in this layer
# handles the Chromium GN build under a separate PN to avoid the multi-version
# conflict with gn-native_git.bb (Qt's 6.8.3 fork) required by qtwebengine.
